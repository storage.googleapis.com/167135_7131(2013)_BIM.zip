Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-09-11T16:08:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 11 16:08:24 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{92902919-B920-4B75-96FD-544294BF151F}\ifc * Database version: 5507 * Database creation date: Tue Sep 11 16:08:23 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 11 16:08:23 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 11 16:08:23 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7131 Shower faucet, 7131(2013):7131 Shower faucet:364662
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 365.3 mm; NominalHeight: 186 mm; NominalWidth: 283.1 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 7131(2013); ConvergoRefNr: 0087-1809-0062-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 30/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150077036; EN Standard: EN 1111; LVI Number: 6310801; Noise Class: II (ISO 3822) Oras lab.; STF Certificate: STF VTT-RTH-00030-15
Type - Identity Data(Type) - Class: Thermostatic; Group: Shower faucets; Manufacturer: Oras; Market: INT;FIN;NOR;POL;LTU;LVA; Model: 7131 Shower faucet; Name_en: 7131 Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7131; Product Datasheet: https://www.oras.com/datasheet/7131/en; Product Family: Oras Optima; Product URL: https://www.oras.com/en/products/oras/product/7131; Type Name: 7131 Shower faucet; Usage Group: Hospitals
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G3/4; Flow: EcoFlow control; Flow Rate At 300kPa: 0.00953496 m3/s; Installation Type: Wall-mounted; Installation Width: CC150± 3 mm; Lever Handle: Easy-Grip Lever; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Litter filter(s), non-return valve(s); Pressure Loss With Flow 02ls: 170000 Pa; Shower Parts: Shower head; Spout Type: Swivel spout; Temperature: Thermostatic temperature control, temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, shower, health & care; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7131(2013); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7131; Name: 7131 Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 285x365x185 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7131; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7131 Shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.225964 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0192396 m3
Identity Data - Mark: 23
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 7131(2013): 7131 Shower faucet; Family and Type: 7131(2013): 7131 Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7131(2013): 7131 Shower faucet; Type Id: 7131(2013): 7131 Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
